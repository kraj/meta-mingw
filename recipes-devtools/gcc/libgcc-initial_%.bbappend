DEPENDS_append_mingw32 = " mingw-w64-headers"
